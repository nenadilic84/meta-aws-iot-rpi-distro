SUMMARY = "replace ntp.conf with sync server"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
