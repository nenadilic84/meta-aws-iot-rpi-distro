SUMMARY = "configure wireless connection"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
